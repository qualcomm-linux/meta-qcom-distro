RDEPENDS:${PN}:append:qcom-distro = " \
    selinux-user-downloads-dir \
"
