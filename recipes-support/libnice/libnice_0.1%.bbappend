PACKAGECONFIG:append:qcom-distro = " gstreamer"
