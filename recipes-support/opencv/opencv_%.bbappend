PACKAGECONFIG:append:pn-opencv = " dnn gstreamer"
