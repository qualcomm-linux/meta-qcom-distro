DEPENDS:remove:qcom-distro = "gstreamer1.0-vaapi"
DEPENDS:append:qcom-distro = " libva"
