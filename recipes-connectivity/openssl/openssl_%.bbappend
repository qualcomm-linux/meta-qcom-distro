PACKAGECONFIG:append:class-target:qcom-distro = " legacy"
