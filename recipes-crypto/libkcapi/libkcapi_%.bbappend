# Enable testapp
PACKAGECONFIG:append:qcom-distro = " testapp"
