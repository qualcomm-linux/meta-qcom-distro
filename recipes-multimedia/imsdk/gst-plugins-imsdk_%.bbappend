PACKAGECONFIG:append = " tflite"
