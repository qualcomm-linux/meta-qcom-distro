FILESEXTRAPATHS:prepend:qcom-distro := "${THISDIR}/files:"
SRC_URI:append:qcom-distro = " file://findfs.cfg"
