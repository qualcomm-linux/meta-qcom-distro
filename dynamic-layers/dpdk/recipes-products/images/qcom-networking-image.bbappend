CORE_IMAGE_BASE_INSTALL += "dpdk"
