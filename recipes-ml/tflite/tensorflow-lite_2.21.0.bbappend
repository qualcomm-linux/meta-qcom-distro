PACKAGECONFIG:append = " gpu"
